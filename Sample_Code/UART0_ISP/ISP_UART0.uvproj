# Keil uVision project ISP_UART0.uvproj, settings and files
target UART_mode_2 (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: ISP_UART0 +hex
  AfterMake: .\output\hex2bin.exe .\output\ISP_UART0.hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\..\Include
  link misc: REMOVEUNUSED
  group Source
    ./Source/: UART0_transfer.c main.c
  group Startup
    ../../Startup/: STARTUP.A51
